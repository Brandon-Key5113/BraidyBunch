# Keil uVision project ManualProj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: ManualProj
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Manual Project;.\Drivers\BSP\Components\Common;.\Drivers\BSP\STM32H7xx_Nucleo;.\Drivers\BSP\X-NUCLEO-IHMxx;.\Drivers\STM32H7xx_HAL_Driver\Inc;.\Drivers\BSP\Components\l6474;.\Drivers\BSP\Components\lan8742
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application
    ./: main.c
  group Drivers/BSP/Components
    ./Drivers/BSP/Components/l6474/: l6474.c
    ./Drivers/BSP/Components/lan8742/: lan8742.c
  group Drivers/BSP/STM32H7xx_Nucleo
    ./Drivers/BSP/STM32H7xx_Nucleo/: stm32h7xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IHMxx
    ./Drivers/BSP/X-NUCLEO-IHMxx/: x_nucleo_ihm01a1_stm32h7xx.c x_nucleo_ihmxx.c
  group Drivers/STM32H7xx_HAL_Driver
    ./Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_timebase_rtc_alarm_template.c stm32h7xx_hal_timebase_rtc_wakeup_template.c stm32h7xx_hal_timebase_tim_template.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_dac.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_gpio.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_utils.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32H743ZITx/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./RTE/Device/STM32H743ZITx/STCubeGenerated/Inc/: stm32h7xx_it.h
software components: CMSIS:CORE 5.3.0, CMSIS Driver:SPI 1.2.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:SPI 1.5.0, Device:Startup 1.5.0
